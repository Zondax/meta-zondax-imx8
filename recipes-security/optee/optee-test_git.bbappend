FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ta-replace-TEE_ATTR_FLAG_VALUE-with-older-TEE_ATTR_B.patch"
